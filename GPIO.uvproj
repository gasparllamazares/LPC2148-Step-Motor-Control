# Keil uVision project GPIO.uvproj, settings and files
target EA LPC2148 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: GPIO +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  link misc: --verbose --list=err.txt
  group StartUp Code
    ./: Startup.s
  group Source Files
    ./: serial.c serial.h GPIO.c
